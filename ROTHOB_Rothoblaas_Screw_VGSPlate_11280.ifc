Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: f976b924-e121-47c1-8792-99e0de494b72, NumberOfSaves: 86], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_Screw_VGSPlate_11280.ifc
Time: 2026-02-25T09:07:05
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Proprietario; Project Issue Date: Data; Project Name: Nome; Project Number: 0001; Project Status: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Proprietario; Project Issue Date: Data; Project Name: Nome; Project Number: 0001; Project Status: Stato

# IfcBuildingStorey: Level:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: 0_Rothoblaas; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: 0_Rothoblaas; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Livello; Type: Livello; Type Id: 927
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Tratto; Line Weight: 1; Symbol: Estremità Livello : Triangolo; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Livello
Other(Type) - Category: Levels; Family Name: Level

# IfcMechanicalFastener: Structural Connections : ROTHOB_Rothoblaas_Screw_VGSPlate : VGSPL11280_11x280mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_Electrogalvanized_Black
Type - Data - AtmosphericCorrosivity: C1 | C2; ServiceClass: SC1 | SC2; WoodCorrosivity: T1 | T2
Type - General - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Screw_VGSPlate; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23.20.40.11.14.24; OmniClassTitle: Screws; OmniClassVersion: 2012-05-16; ProductInformation: www.rothoblaas.com/products/fastening/screws/vgs-plate; Revision: 000; UniClass2015Code: Pr_20_29_76_75; UniClass2015Title: Self-tapping screws; UniClass2015Version: Products v1.41; Version: 001
Type - Constraints - Default Elevation: 1219.2 mm; ModelNumberCode: 11280
Type - Mechanical - AssociatedDensity_ρa_BeechLVLPredrilled: 730 kg/m3; AssociatedDensity_ρa_LVLSoftwood: 500 kg/m3; AssociatedDensity_ρa_Softwood: 350 kg/m3; CalculationDensity_ρk_BeechLVLPredrilled: 590 ÷ 750 kg/m³; CalculationDensity_ρk_LVLSoftwood: 460 ÷ 550 kg/m³; CalculationDensity_ρk_Softwood: ≤ 440 kg/m³; TensileStrength_ftens,k: 38 kN; WithdrawalResistance_BeechLVLPredrilled: 29000; WithdrawalResistance_LVLSoftwood: 15000; WithdrawalResistance_Softwood: 11700; YieldMoment_My,k: 45.9 kg*m2/s2
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_Electrogalvanized_Black
Type - Dimensions - HeadDiameter_dk: 20 mm; HeadDiameterS_dks: 16.5 mm; HeadThickness_t1: 16.25 mm; HeadWasherThickness_twt: 2.5 mm; HexagonalHeadThickness_ts: 5.75 mm; HoleDiameterOnSteelPlate_dvs: 13 mm; InsertionLength_L: 280 mm; NominalDiameter_d1: 11 mm; PredrillingHoleDiameterHardwood_dvh: 7 mm; PredrillingHoleDiameterSoftwood_dvs: 6 mm; ThreadDiameter_d2: 6.6 mm; ThreadLength_b: 270 mm; TipLength_Lt: 13.2 mm; UnderheadDiameter_duk: 12 mm; UnderheadLength_L1: 3 mm; WrenchSize_SW: 17 mm
Type - Identity Data - Description: Pan Head Hexagonal Screw for lifting; Manufacturer: info@rothoblaas.com; OmniClass Number: 23.20.40.11.14.24; OmniClass Title: Screws; Type Name: VGSPL11280_11x280mm
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: Fixed; CECode: ETA-11/0030; CETitle: Rotho Blaas Self-tapping screws and threaded rods; CodePerformance: CE - Construction products; Color: Black; Constituents: n/a; Description_2: Pan Head Hexagonal Screw for lifting; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Screw_VGSPlate; Features: Full-threaded screw for lifting or steel-timber connection; Finish: Black zinc plated; Grade: n/a; GTIN: 8055598651761; ICC-ESCode: ESR-4645 | ELC-4645; ICC-ESTitle: Rotho blaas self-tapping wood screws | Rotho Blaas Self-tapping Wood Screws; Manufacturer_2: info@rothoblaas.com; Material: Electrogalvanized carbon steel; MinWeight: 0.118 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: VGSPL11280; ModelReference: n/a; Name: Screw; NominalDiameter: 11 mm; NominalHeight: n/a; NominalLength: 280 mm; NominalWidth: n/a; ReplacementCost: n/a; Shape: Cylindrical; Size: 11x280 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Black
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Screw
Pset_QuantityTakeOff - Reference: VGSPL11280_11x280mm
Constraints - Elevation from Level: 0 mm; Host: Level : 0_Rothoblaas; Level: 0_Rothoblaas; Schedule Level: 0_Rothoblaas
Phasing - Phase Created: Stato di Progetto
Dimensions - Area: 0.00360483 m2; Volume: 0.0000115489 m3
Other - Family: ROTHOB_Rothoblaas_Screw_VGSPlate; Family and Type: ROTHOB_Rothoblaas_Screw_VGSPlate: VGSPL11280_11x280mm; Type: VGSPL11280_11x280mm; Type Id: 963483
